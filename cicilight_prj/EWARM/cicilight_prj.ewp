# IAR project cicilight_prj.ewp, settings and files
configuration cicilight_prj (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE; IO_CHECK_TASK_ENABLE=1
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ../libraries/log; ../libraries/util; ../libraries/SEGGER_RTT_V612j/RTT; ../libraries/SEGGER_RTT_V612j/Syscalls; ../Src/user_tasks; ../Middlewares/Third_Party/freemodbus/port; ../Middlewares/Third_Party/freemodbus/modbus/functions; ../Middlewares/Third_Party/freemodbus/modbus/rtu; ../Middlewares/Third_Party/freemodbus/modbus/include; ../Drivers/BSP/components/drv8711; ../Drivers/BSP/components/rgb_led; ../Drivers/BSP/components/ntc; ../Drivers/BSP/common; ../Drivers/BSP/cicilight_v1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: cicilight_prj.bin
  ILINK.IlinkOutputFile: cicilight_prj.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: adc.c dma.c freertos.c gpio.c main.c spi.c stm32f1xx_hal_msp.c stm32f1xx_it.c tim.c usart.c
  group Application/User/user
    ../Src/user_tasks/: io_check_task.c mb_reg.c user_tasks.c
  group Drivers/BSP/cicilight_v1
    ../Drivers/BSP/cicilight_v1/: JJDK_ZK_GZ1.c
  group Drivers/BSP/components/drv8711
    ../Drivers/BSP/components/drv8711/: drv8711.c
  group Drivers/BSP/components/ntc
    ../Drivers/BSP/components/ntc/: ntc_3950.c
  group Drivers/BSP/components/rgb_led
    ../Drivers/BSP/components/rgb_led/: rgb_led.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group libraries/log
    ../libraries/log/: app_log.c app_log_port.c
  group libraries/segger_rtt_v612j/rtt
    ../libraries/SEGGER_RTT_V612j/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group libraries/segger_rtt_v612j/syscalls
    ../libraries/SEGGER_RTT_V612j/Syscalls/: SEGGER_RTT_Syscalls_IAR.c
  group libraries/util
    ../libraries/util/: app_error.c
  group Middlewares/freemodbus/modbus
    ../Middlewares/Third_Party/freemodbus/modbus/: mb.c
  group Middlewares/freemodbus/modbus/functions
    ../Middlewares/Third_Party/freemodbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group Middlewares/freemodbus/modbus/rtu
    ../Middlewares/Third_Party/freemodbus/modbus/rtu/: mbcrc.c mbrtu.c
  group Middlewares/freemodbus/port
    ../Middlewares/Third_Party/freemodbus/port/: portevent.c portother.c portserial.c porttimer.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
