# Keil uVision project cicilight_prj.uvprojx, settings and files
target cicilight_prj (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: cicilight_prj +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99 --locale=english
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;../Drivers/BSP/cicilight_v1;../Drivers/BSP/common;../Drivers/BSP/components/ntc;../Drivers/BSP/components/drv8711;../Drivers/BSP/components/rgb_led;../src/user_tasks;../libraries/log;../libraries/SEGGER_RTT_V612j/RTT;../libraries/util;../libraries/SEGGER_RTT_V612j/Syscalls;../Middlewares/Third_Party/freemodbus/modbus/functions;../Middlewares/Third_Party/freemodbus/modbus/rtu;../Middlewares/Third_Party/freemodbus/modbus/include;../Middlewares/Third_Party/freemodbus/port
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: adc.c spi.c stm32f1xx_hal_msp.c freertos.c dma.c stm32f1xx_it.c gpio.c main.c usart.c tim.c
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/user_tasks
    ../Src/user_tasks/: io_check_task.c mb_reg.c user_tasks.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_dma.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_cortex.c stm32f1xx_hal_tim.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_adc.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/BSP/cicilight_v1
    ../Drivers/BSP/cicilight_v1/: JJDK_ZK_GZ1.c
  group Drivers/BSP/components/drv8711
    ../Drivers/BSP/components/drv8711/: drv8711.c
  group Drivers/BSP/components/rgb_led
    ../Drivers/BSP/components/rgb_led/: rgb_led.c
  group Drivers/BSP/components/ntc
    ../Drivers/BSP/components/ntc/: ntc_3950.c
  group libraries/log
    ../libraries/log/: app_log.c app_log_port.c
  group libraries/rtt
    ../libraries/SEGGER_RTT_V612j/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../libraries/SEGGER_RTT_V612j/Syscalls/: SEGGER_RTT_Syscalls_KEIL.c
  group libraries/error
    ../libraries/util/: app_error.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: list.c tasks.c event_groups.c croutine.c queue.c timers.c
  group Middleware/modbus
    ../Middlewares/Third_Party/freemodbus/modbus/functions/: mbfuncholding.c mbfuncinput.c mbutils.c
    ../Middlewares/Third_Party/freemodbus/modbus/: mb.c
    ../Middlewares/Third_Party/freemodbus/modbus/rtu/: mbcrc.c mbrtu.c
  group Middleware/modbus/port
    ../Middlewares/Third_Party/freemodbus/port/: portevent.c portother.c portserial.c porttimer.c
software components: CMSIS:CORE 4.1.0
